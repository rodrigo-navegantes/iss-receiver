options:
  parameters:
    generate_options: qt_gui
    id: sinal
    output_language: python
    title: ISS RX Test
  states: {}

blocks:
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: decim
  id: variable
  parameters:
    value: '25'
  states: {}
- name: record_rate
  id: variable
  parameters:
    value: channel_rate * 3 / 4
  states: {}
- name: rf_center
  id: variable
  parameters:
    value: target_frequency + rf_offset
  states: {}
- name: rf_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rf_offset'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 30e3, 10e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: iq_output
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iss_145825_240k.c64"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: record_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: record_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: 8e6
    center_freq: rf_center
    dev_args: driver=hackrf
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: target_frequency
  id: parameter
  parameters:
    type: eng_float
    value: 145.825e6
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
