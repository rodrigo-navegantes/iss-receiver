options:
  parameters:
    generate_options: qt_gui
    id: sinal
    output_language: python
    title: ISS RX Test
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: decim
  id: variable
  parameters:
    value: '25'
  states: {}
- name: record_rate
  id: variable
  parameters:
    value: int(channel_rate * 3 / 4)
  states: {}
- name: rf_center
  id: variable
  parameters:
    value: target_frequency + rf_offset
  states: {}
- name: rf_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: record_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/rodrigo/Documents/IC/PdQSat/ISS/baofeng_rx.wav
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Remove o nivel DC causado por pequeno erro de sintonia
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rf_offset'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 30e3, 10e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: iq_output
  id: parameter
  parameters:
    type: str
    value: '"/tmp/baofeng_240k.c64"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: record_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: record_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.4'
    interp: '3'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: 8e6
    center_freq: rf_center
    dev_args: driver=hackrf
    gain: '0'
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {}
- name: target_frequency
  id: parameter
  parameters:
    type: eng_float
    value: 145.4910e6
  states: {}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
